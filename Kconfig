## Kconfig
```kconfig
config MCUX_COMPONENT_middleware.cjson
    bool "CJSON"
    default n
    help
        Enable middleware.cjson component
```
